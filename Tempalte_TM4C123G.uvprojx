# Keil uVision project Tempalte_TM4C123G.uvprojx, settings and files
target Tempalte_TM4C123G (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506_960)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tempalte_TM4C123G
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..\..\Drivers\CMSIS\TM4C123Gxx\inc;..\..\Drivers\TM4C123G_Driver\driverlib;..\..\Drivers\TM4C123G_Driver\inc;..\..\User_Task\TM4C123G;..\..\Core\TM4C123Gxx\Src;..\..\Core\TM4C123Gxx\Inc;..\..\Drivers\CMSIS\TM4C123Gxx\utils;..\..\Drivers\CMSIS\TM4C123Gxx;..\..\BSP;..\..\User_Task\Task_control
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../../Drivers/CMSIS/TM4C123Gxx/: startup_rvmdk.S
  group Application/User
    ../../User_Task/TM4C123G/: main.c scheduler.c
  group Application/User/Task_Ctrl
    ../../User_Task/Task_control/: tempalte.c
  group Application/User/Core
    ../../Core/TM4C123Gxx/Src/: i2c_user.c spi_user.c sys_user.c gpio_user.c
  group Application/User/BSP
    ../../BSP/LED/: led.c
    ../../BSP/KEY/: key.c
    ../../BSP/OLED/: oled.c oled_data.c
  group Drivers/TM4C123G_Driver
    ../../Drivers/TM4C123G_Driver/driverlib/: ssi.c lcd.c i2c.c crc.c qei.c fpu.c epi.c cpu.c can.c uart.c usb.c adc.c des.c aes.c mpu.c gpio.c pwm.c flash.c timer.c emac.c udma.c sysctl.c comp.c systick.c sw_crc.c sysexc.c eeprom.c onewire.c interrupt.c shamd5.c hibernate.c watchdog.c
